# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Config.h Delay.c Delay.h GPIO.c GPIO.h NVIC.c NVIC.h STC8H_PWM.c STC8H_PWM.h STC8H_PWM_Isr.c Switch.h UART.c UART.h UART_Isr.c
