# Keil uVision project stc8h8k64u.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: stc8h8k64u +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Lib;.\User;.\App
  group User
    ./User/: main.c
  group Lib
    ./Lib/: GPIO.c NVIC.c UART.c UART_Isr.c ADC.c Delay.c STC8H_PWM.c
  group Driver
    ./Driver/: Light.c Light.h Key.c Key.h Battery.c Battery.h Buzzer.c Buzzer.h Ultrasonic.c Ultrasonic.h Motors.c Motors.h TrackSensor.c TrackSensor.h
  group App
    ./App/: App.h App_Key.c App_RC.c App_RC.h App_System.c App_Track.c App_Track.h App_Vehicle.c App_Vehicle.h
