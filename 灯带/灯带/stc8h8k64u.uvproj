# Keil uVision project stc8h8k64u.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: stc8h8k64u +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Driver;.\Lib;.\User
  group User
    ./User/: main.c
  group Lib
    ./Lib/: GPIO.c NVIC.c UART.c UART_Isr.c
  group Driver
    ./Driver/: Light.c Light.h
    ./: WS2812.c WS2812.h
